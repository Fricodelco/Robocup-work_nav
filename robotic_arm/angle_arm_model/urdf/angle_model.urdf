Commit message: small fixes

File: robotic_arm/angle_arm_model/urdf/angle_model.urdf (robot description, URDF)
Before this commit: robot angle_robot, 10 links, 9 joints
Joints:
- joint camera_joint: origin xyz=-0.032 0.035 -0.08 rpy=1.57 0 -1.57 -> xyz=-0.040 0.035 -0.070 rpy=1.57 0 -1.57
